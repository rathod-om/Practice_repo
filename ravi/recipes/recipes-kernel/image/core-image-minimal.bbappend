IMAGE_INSTALL:append = " dropbear openssh-scp i2c-tools"  
