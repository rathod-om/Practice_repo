FILESEXTRAPATHS:prepend := "${THISDIR}/linux-yocto:"

SRC_URI += "file://0001-add-EAAPMST3923A2.c-driver-Makefile-and-kconfig.patch \
	file://0001-added-proper-address.patch \	
	file://0001-am33x-upadted.patch \
	file://enabled-EAAPMST3923A2.cfg \
"

