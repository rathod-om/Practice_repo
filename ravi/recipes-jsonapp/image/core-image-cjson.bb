require recipes-core/images/core-image-minimal.bb


IMAGE_INSTALL:append = " cjsonlib cjsoncode util-linux"
